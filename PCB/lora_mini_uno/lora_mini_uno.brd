# Repository Next-step-Fukuoka/Fukuoka-City-LoRaWAN

## EAGLE design PCB/lora_mini_uno/lora_mini_uno.brd

Parts:
ANT: PINHD-1X1; 1X01
C1: 100uF; 153CLV-0505
C2, C3, C8, C10, C12: 0.1uF; C0603K
C9, C11: 1uF; C0603K
C13: 0.01uF; C0603K
CN1: ST-MC-5F-01
D1, D2: MBR0520LT1G; SOD3716X135N
F1: 500mA; R1206
G1: 2.1MMJACKTHM; PJ-102A
IC1: FT232RL; SSOP28
J1: 4P-2.0; HW4-2.0
J2: TSW-105-02-S-S
JP1: ARDUINO_R3
JP2, JP4: PINHD-1X12-CB; 1X12-CB
LED1, LED2, LED3, LED4: LED0603; LED-0603
R1, R4, R5: 10k; R0603
R2, R3, R6, R7, R8, R9: 1k; R0603
SW1: RESET; SWITCH_3X6X5MM
U1: ADP3338AKC-5; SOT223
U2: ADP3338AKCZ-3.3; SOT223
U3: LORA_MINIB; LORA_MINI_PCB

Connections:
+3V3: C1.+, C2.1, C3.1, C11.1, C12.1, IC1.20 (VCC), J1.3, JP1.3.3V, JP1.VCC, JP2.9, R1.2, R4.2, R5.2, R6.2, R7.2, R9.1, U2.2 (OUT), U2.4 (OUT), U3.9 (3.3V); also elsewhere on the board
+5V: C10.1, D1.C, D2.C, JP1.5V, U2.3 (IN)
A0: JP1.A0, JP4.11, U3.14 (A0)
A1: JP1.A1, JP4.10, U3.15 (A1)
A2: JP1.A2, JP4.9, U3.16 (A2)
A3: JP1.A3, JP4.8, U3.17 (A3)
A4: J1.2, JP1.A4, JP1.SDA, JP4.7, R5.1, U3.18 (A4); also elsewhere on the board
A5: J1.1, JP1.A5, JP1.SCL, JP4.6, R4.1, U3.19 (A5); also elsewhere on the board
A6: J2.5, JP4.5, U3.20 (A6)
A7: J2.4, JP4.4, U3.21 (A7)
AREF: JP1.AREF, JP4.12, U3.13 (AREF)
D2: JP1.D2
D3: JP1.D3 (*D3), JP2.5, U3.5 (D3)
D4: JP1.D4, JP2.6, U3.6 (D4)
D5: JP1.D5 (*D5), JP2.8, R8.1, U3.8 (D5)
D6: JP1.D6 (*D6)
D7: JP1.D7
D8: JP1.D8
D9: JP1.D9 (*D9)
D10: JP1.D10 (*D10)
D11: JP1.D11 (*D11)
D12: JP1.D12
D13: JP1.D13
D+: CN1.DP, IC1.15 (USBDP)
D-: CN1.DN, IC1.16 (USBDM)
GND: C1.-, C2.2, C3.2, C8.2, C9.2, C10.2, C11.2, C12.2, CN1.GND@1 (GND), CN1.GND@2 (GND), CN1.GND@3 (GND), G1.RING, G1.RING_SW, IC1.7 (GND), IC1.18 (GND), IC1.21 (GND), IC1.25 (GND), IC1.26 (TEST), J1.4, JP1.GND@1 (GND), JP1.GND@2 (GND), JP1.GND@3 (GND), JP1.GND@4 (GND), JP2.7, JP4.1, LED1.C, LED2.C, SW1.P$1, U1.1 (ADJ), U2.1 (ADJ), U3.7 (GND), U3.24 (GND), U3.26 (GND); also elsewhere on the board
LORA_DIO3: J2.2, JP4.2, U3.23 (LORA_DIO3)
LORA_DIO4: J2.3, JP4.3, U3.22 (LORA_DIO4)
LORA_NSS: J2.1, JP2.4, U3.4 (LORA_NSS)
MISO: JP1.MISO, JP2.10, U3.10 (MISO)
MOSI: JP1.MOSI, JP2.11, U3.11 (MOSI)
unnamed: IC1.22 (CBUS1), LED3.C
unnamed: IC1.23 (CBUS0), LED4.C
unnamed: CN1.VUSB, F1.2
unnamed: IC1.1 (TXD), R2.1
unnamed: IC1.4 (VCCIO), IC1.17 (3V3OUT), IC1.19 (!RESET)
unnamed: C13.1, IC1.2 (!DTR)
unnamed: IC1.5 (RXD), R3.1
unnamed: ANT.1, U3.25 (ANT)
unnamed: LED2.A, R8.2
unnamed: C9.1, D2.A, U1.2 (OUT), U1.4 (OUT)
unnamed: D1.A, F1.1
PWR-LED: LED1.A, R9.2
RESET: C13.2, JP1.RESET@1 (!RESET!), JP1.RESET@2 (!RESET!), JP2.1, R1.1, SW1.P$2, U3.1 (RESET)
RTS: IC1.3 (!RTS)
RX: JP1.D0, JP2.2, R2.2, U3.2 (RXI)
RX-LED: LED3.A, R6.1
SCK: JP1.SCK, JP2.12, U3.12 (SCK)
TX: JP1.D1, JP2.3, R3.2, U3.3 (TXO)
TX-LED: LED4.A, R7.1
VDD: C8.1, G1.TIP, JP1.VIN, U1.3 (IN)

Notes on the sheet:
NextStep ESP-WROOM32 UNO Board

Parts:
C4, C5, C6, C7: 0.1uF; C0603K
IC2: SHT21
IC3: ADXL345; LGA-14
IC4: MPL3115A2; LGA-8-5X3
R10: 10k; R0603

Connections:
+3V3: C4.1, C6.1, C7.2, IC2.5 (V+), IC3.1 (VDD), IC3.6 (VS), IC4.1 (VDD), IC4.4 (VDDIO), R10.1; also elsewhere on the board
A4: IC2.1 (SDA), IC3.13 (SDA), IC4.7 (SDA); also elsewhere on the board
A5: IC2.6 (SCL), IC3.14 (SCL), IC4.8 (SCL); also elsewhere on the board
GND: C4.2, C5.2, C6.2, C7.1, IC2.2 (GND), IC2.P$1 (GND), IC3.2 (GND), IC3.4 (GND), IC3.5 (GND), IC3.12 (SDO), IC4.3 (GND); also elsewhere on the board
unnamed: IC3.7 (CS), R10.2
unnamed: C5.1, IC4.2 (CAP)

Notes on the sheet:
温湿度センサー
3軸加速度センサー

Board: 2 copper layers, 68.6 x 53.3 mm, 46 parts (0 on the bottom side), 43 nets.

## Commit log

2017-10-14 初回登録

Notices in the files:
parts and their libraries:
SparkFun-Boards: Licensing: Creative Commons ShareAlike 4.0 International - https://creativecommons.org/licenses/by-sa/4.0
